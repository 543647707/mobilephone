# Keil uVision project mobilephone.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mobilephone +hex
  c flags: Optim=1 wLevel=2
  c include: .\RTE\Device\STM32F103ZE\Ucos\Core;.\RTE\Device\STM32F103ZE\Ucos\Config;.\RTE\Device\STM32F103ZE\Ucos\Ports;..\..\Ucos\Config
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./RTE/Device/STM32F103ZE/User/: main.c usart.c key.c GUI.c Lcd_Driver.c QDTFT_demo.c delay.c
  group Ucos_Core
    ./RTE/Device/STM32F103ZE/Ucos/Core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Ucos_Config
    ./RTE/Device/STM32F103ZE/Ucos/Config/: includes.h os_cfg.h
  group Ucos_Ports
    ./RTE/Device/STM32F103ZE/Ucos/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg_r.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.1.0/Device/StdPeriph_Driver/src/: stm32f10x_cec.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_dma.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.1.0/RTE_Driver/: GPIO_STM32F10x.c
    RTE/Device/STM32F103ZE/: RTE_Device.h startup_stm32f10x_hd.s system_stm32f10x.c stm32f10x_conf.h
software components: CMSIS:CORE 3.30.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
